# Keil uVision project blinky_STM32F091RC_NUCLEO.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F091RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: blinky_STM32F091RC_NUCLEO
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.3.0, Board Support:LED 1.1.0, Device:STM32Cube Framework:STM32CubeMX 1.0.0, Device:Startup 2.3.3
