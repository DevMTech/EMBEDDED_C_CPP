# Keil uVision project 0_GETTING_STARTED.uvprojx, settings and files
target 0_GETTING_STARTED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F091RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: 0_GETTING_STARTED +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F091xC
  c include: ../Core/Inc;   ../Drivers/STM32F0xx_HAL_Driver/Inc;   ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;   ../Drivers/CMSIS/Include;   ../Middlewares/ST/BlueNRG-MS/utils;   ../Middlewares/ST/BlueNRG-MS/includes;   ../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic;  ../BlueNRG_MS/App;  ../BlueNRG_MS/Target
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f091xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f0xx_nucleo_bus.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Middlewares/BlueNRG-MS/Wireless/BlueNRG-MS/Utils
    ../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
  group Middlewares/BlueNRG-MS/Wireless/BlueNRG-MS/Controller
    ../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils_small.c
  group Middlewares/BlueNRG-MS/Wireless/BlueNRG-MS/HCI_TL/Basic
    ../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Application/User/BlueNRG_MS/App
    ../BlueNRG_MS/App/: eddystone_beacon.c sensor_service.c app_bluenrg_ms.c
  group Application/User/BlueNRG_MS/Target
    ../BlueNRG_MS/Target/: hci_tl_interface.c
  group Doc
    D:/UBUNTU-VBOX-SHARED-FOLDER/GITHUB/EMBEDDED_C_CPP/STM32CUBEMXWorkSpace/STM32_BLE_PROJ/0_GETTING_STARTED/: readme.txt
software components: CMSIS:CORE 4.3.0
